# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __MSP432P401R__
  c misc: --diag_suppress=1
  c include: ..\Lib\driverlib\MSP432P4xx;..\Lib\inc;..\Lib\inc\CMSIS;..\User;..\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Startup
    ./RTE/Device/MSP432P401R/: startup_msp432p401r_uvision.s system_msp432p401r.c
  group Lib
    F:/keil for mdk/MSP432/template/Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../Hardware/src/: delay.c sys.c led.c EXTI.c isr.c key.c soft_interrupt.c myuart.c TimerA.c servo.c OLED.c MyGPIO.c OLED_SPI.c VOFA.c
  group User
    ./: main.c main.h
